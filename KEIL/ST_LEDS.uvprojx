# Keil uVision project ST_LEDS.uvprojx, settings and files
target ST_LEDS (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ST_LEDS +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=2
  c include: Z:\ST_LEDS;.\CMSIS\inc;..\SOURCE\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./CMSIS/StartUp/: startup_stm32f10x_ld.s
  group Source
    ../SOURCE/src/: main.c setting.c ws2811.c lighting.c
